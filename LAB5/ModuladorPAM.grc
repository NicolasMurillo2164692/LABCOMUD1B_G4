options:
  parameters:
    author: Nicolas_Murillo
    category: '[ModulosD1B_G4]'
    copyright: UIS
    description: D1B_G4
    generate_options: hb
    id: ModuladorPAM
    output_language: python
    title: Modulador PAM
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fs
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 50-d
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: d
  id: parameter
  parameters:
    label: ancho del pulso
    type: intx
    value: '10'
  states: {}
- name: fs
  id: parameter
  parameters:
    label: frecuencia de señal cuadrada
    value: '100000'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: frecuencia de muestreo
    value: '100000'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_multiply_xx_1, '0', pad_sink_1, '0']
- [blocks_multiply_xx_1_0, '0', blocks_multiply_xx_1, '1']
- [pad_source_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
