options:
  parameters:
    author: Nicolas_Murillo_2164692
    copyright: UIS
    description: ModulacionPM_estudianteUIS_comuI
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: ModulacionPM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '4'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia Mensaje
    orient: Qt.Horizontal
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    orient: Qt.Horizontal
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Calculopotencia_0
  id: Calculopotencia
  parameters:
    I_vect: '1024'
  states: {}
- name: EnvolventecomplejaPM_0
  id: EnvolventecomplejaPM
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventecomplejaPM_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventecomplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaPM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaPM_0, '0']
- [blocks_complex_to_mag_0, '0', Calculopotencia_0, '0']

metadata:
  file_format: 1
